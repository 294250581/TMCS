# Keil uVision project utLIB.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: utLIB (library)
  c flags: Optim=1
  c include: ..\..\utLIB;..\..\utLIB\utOsal;..\..\utLIB\utPrt;..\..\utLIB\utFIFO;..\..\utLIB\utSPI;..\..\utLIB\utZLG7289;..\McuHal\utConfig;..\McuHal\utBoard;..\McuHal\utMCU;..\McuHal\utEvtProc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../McuHal/utMcu/: cpu_a.asm utMcu.c
    ../../utLIB/utOsal/: utOsal.c
    ../../utLIB/utPrt/: utPrt.c
    ../../utLIB/utFIFO/: utFIFO.c
