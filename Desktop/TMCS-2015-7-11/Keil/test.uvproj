# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test +hex
  AfterMake: fromelf.exe --bin -o @p.bin @p.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\USER\Startup\inc;..\lib\StdPeriphDriver\inc;..\USER;..\utLIB\utOsal;..\McuHal\utBoard;..\McuHal\utEvtProc;..\McuHal\utConfig;..\McuHal\utMcu;..\utLIB;..\utLIB\utPrt;..\Code\Encoder;..\Code\dSPIN;..\Code\Motor;..\Code\CAN;..\Code\PROCESS;..\Code\Flash;..\Code\BSP;..\Code\Iobus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StartUp
    ../USER/Startup/src/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STM32LIB
    ../lib/: STM32F10xR3.lib
  group Main
    ../USER/: main.c stm32f10x_it.c
  group utLIB
    ../McuHal/utMcu/: utMcu.c cpu_a.asm
    ../utLIB/utOsal/: utOsal.c
  group McuHal
    ../McuHal/utBoard/: utBoard.c utTest.c
    ../McuHal/utEvtProc/: utEvtProc.c
    ../utLIB/utPrt/: utPrt.c
  group Encoder
    ../Code/Encoder/: encoder.c
  group dSPIN
    ../Code/dSPIN/: dSPIN.c
  group Motor
    ../Code/Motor/: motor.c motor_cal.c motor_config.c
  group CAN
    ../Code/CAN/: can_network.c can_receive.c can_configure.c
  group PROCESS
    ../Code/PROCESS/: Tmcs_process.c
  group FLASH
    ../Code/Flash/: Flash.c
  group BSP
    ../Code/BSP/: Tmcs_bsp.c
  group Iobus
    ../Code/Iobus/: Iobus.c
